Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2]
Time: 2023-12-22T11:51:29
Written by: ODA IFC SDK 22.8
Made in: 22.1.30.34 - Exporter 22.1.30.34 - Alternate UI 22.1.30.34

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 ft
Pset_SiteCommon - Reference: Informações do projeto
Outros - Categoria: Informações do projeto

# IfcBuilding
Pset_BuildingCommon - Reference: Informações do projeto; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Informações do projeto; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Informações do projeto; sets with these values: 2
Outros - Categoria: Informações do projeto

# IfcBuildingStorey: Nível:Nível 1, Nível 1
LongName: Nível 1; Elevation: 0 ft
Pset_BuildingStoreyCommon - Reference: Nível 1
Cotas - Cálculo da altura: 0 ft
Dados de identidade - Andar da construção: yes; Estrutural: no; Nome: Nível 1
Outros - Categoria: Níveis; Família: Nível; Família e tipo: Nível: Nível 1; ID de tipo: 1813; Tipo: Nível 1
Restrições - Elevação: 0 ft
Dados de identidade(Type) - Nome do tipo: Nível 1
Gráficos(Type) - Cor: 0; Espessura da linha: 1; Padrão de linha: Sólido; Símbolo no final 1 padrão: no; Símbolo no final 2 padrão: yes
Outros(Type) - Categoria: Níveis; Nome da família: Nível
Restrições(Type) - Base da elevação: Ponto base do projeto

# IfcBuildingElementProxy: Bosch_Detection Field_CTN_ISC-BDL2-W12GE:Standard, Bosch_Detection Field_CTN_ISC-BDL2-W12GE:Standard:49460
In: Nível 1
Type - Material: R_Bosch, I_Bosch
Type - Dados de identidade - Nome do tipo: Standard
Type - Outros - Categoria: Modelos genéricos; Nome da família: Bosch_Detection Field_CTN_ISC-BDL2-W12GE
Type - Restrições - Elevação-padrão: 4 ft
Type - Pset_BuildingElementProxyCommon - IsExternal: no
Pset_BuildingElementProxyCommon - Reference: Standard
Pset_EnvironmentalImpactIndicators - Reference: Standard
Cotas - Área: 9476.55 ft2; D_Distance: 2310 ft; EndCtrl: 47 deg; FOVDistance: 13.1234 ft; FOVVer: 61.5625 deg; FOVVerReal: 63.5625 deg; HorFOV: 94 deg; I_Distance: 231 ft; O_Distance: 916.667 ft; R_Distance: 462 ft; Rad: 0.00351827 ft; StartCtrl: -47 deg; VoidDist: 2310.25 ft; Volume: 46650 ft3
Fases - Fase criada: Construção nova
Geometria da divisão - BackAct: 7500 ft; Base: 7500 ft; BottAct: 7493.44 ft; FrontAct: 7450.79 ft; LeftAct: 7475.39 ft; RightAct: 7475.39 ft; TopAct: 7491.47 ft
Geral - BDesired: 0 ft; BoDesired: 6.56168 ft; FDesired: 49.2126 ft; LDesired: 24.6063 ft; RDesired: 24.6063 ft; TDesired: 8.53018 ft
Gráficos - Upright Angle: 0 deg; Pan: 0 deg; Tilt: -30 deg; Visible: no
Materiais e acabamentos - Material: I_Bosch
Outros - DORI: yes; Tipo: Standard; Família: Bosch_Detection Field_CTN_ISC-BDL2-W12GE; Família e tipo: Bosch_Detection Field_CTN_ISC-BDL2-W12GE: Standard; ID de tipo: 17188; ManualFOV: yes
Restrições - Move com elementos próximos: no; Nível: Nível 1; Deslocamento do hospedeiro: 7.23689 ft; Elevação do nível: 7.23689 ft; Hospedeiro: Nível : Nível 1

# IfcBuildingElementProxy: Bosch_Detection Field_CTN_ISC-BDL2-W12GE_2:Standard, Bosch_Detection Field_CTN_ISC-BDL2-W12GE_2:Standard:49461
In: Nível 1
Type - Material: I_Bosch2, R_Bosch2
Type - Dados de identidade - Nome do tipo: Standard
Type - Outros - Categoria: Modelos genéricos; Nome da família: Bosch_Detection Field_CTN_ISC-BDL2-W12GE_2
Type - Restrições - Elevação-padrão: 4 ft
Type - Pset_BuildingElementProxyCommon - IsExternal: no
Pset_BuildingElementProxyCommon - Reference: Standard
Pset_EnvironmentalImpactIndicators - Reference: Standard
Cotas - Área: 482.949 ft2; D_Distance: 2310 ft; EndCtrl: 47 deg; FOVDistance: 13.1234 ft; FOVVer: 74.7812 deg; FOVVerReal: 63.5625 deg; HorFOV: 94 deg; I_Distance: 231 ft; O_Distance: 916.667 ft; R_Distance: 462 ft; Rad: 0.00351827 ft; StartCtrl: -47 deg; VoidDist: 2310.25 ft; Volume: 746.565 ft3
Fases - Fase criada: Construção nova
Geometria da divisão - BackAct: 7500 ft; Base: 7500 ft; BottAct: 7491.47 ft; FrontAct: 7450.79 ft; LeftAct: 7475.39 ft; RightAct: 7475.39 ft; TopAct: 7493.44 ft
Geral - BDesired: 0 ft; BoDesired: 8.53018 ft; FDesired: 49.2126 ft; LDesired: 24.6063 ft; RDesired: 24.6063 ft; TDesired: 6.56168 ft
Gráficos - Upright Angle: 0 deg; Pan: 0 deg; Visible: no; Tilt: 74 deg
Materiais e acabamentos - Material 2: I_Bosch2
Outros - DORI: yes; Tipo: Standard; ManualFOV: yes; Família: Bosch_Detection Field_CTN_ISC-BDL2-W12GE_2; Família e tipo: Bosch_Detection Field_CTN_ISC-BDL2-W12GE_2: Standard; ID de tipo: 17251
Restrições - Move com elementos próximos: no; Nível: Nível 1; Deslocamento do hospedeiro: 7.49224 ft; Elevação do nível: 7.49224 ft; Hospedeiro: Nível : Nível 1

# IfcBuildingElementProxy: D_Detection Field FOV2:Standard, D_Detection Field FOV2:Standard:49459
In: Nível 1
Type - Material: Xtech_Bosch_ABS_White
Type - Dados de identidade - Nome do tipo: Standard
Type - Materiais e acabamentos - Lens Material: I_Bosch
Type - Mecânica - Classificação: Nenhum
Type - Outros - Categoria: Equipamento mecânico; Nome da família: D_Detection Field FOV2
Type - Restrições - Elevação-padrão: 6.56168 ft
Type - Pset_BuildingElementProxyCommon - IsExternal: no
Pset_BuildingElementProxyCommon - Reference: Standard
Pset_EnvironmentalImpactIndicators - Reference: Standard
Cotas - Área: 0.000336372 ft2; Volume: 0.00988638 ft3
Dados de identidade - Marca: 3
Fases - Fase criada: Construção nova
Geral - BDesired: 0 ft; FDesired: 49.2126 ft; LDesired: 24.6063 ft; Lower FOV Limit Desired: 6.56168 ft; RDesired: 24.6063 ft; Upper FOV Limit Desired: 8.53018 ft
Materiais e acabamentos - Lens Material 2: I_Bosch2; Material: Bosch_RAL9003
Outros - Família: D_Detection Field FOV2; Família e tipo: D_Detection Field FOV2: Standard; ID de tipo: 17219; Tipo: Standard
Restrições - Deslocamento do hospedeiro: 6.88976 ft; Distance to Object: 0.328084 ft; DORI: yes; Elevação do nível: 6.88976 ft; FOVActual Horizontal Angle: 100 deg; FOV Pan Actual: 0 deg; FOV Tilt Actual1: -30 deg; FOV Tilt Actual2: 74 deg; Hospedeiro: Nível : Nível 1; Move com elementos próximos: no; Nível: Nível 1; Show Manual Field of View: yes; Upright Angle: 0 deg; z Angle Pan Actual: 0 deg; z Angle Tilt Actual: 30 deg; z Angle Tilt Actual 2: -74 deg
